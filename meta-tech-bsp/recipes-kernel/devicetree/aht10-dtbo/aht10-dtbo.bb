SUMMARY = "Recipe for aht10 fragment"
LICENSE = "CLOSED"

SRC_URI = "file://AHT10.dts"

inherit devicetree

COMPATIBLE_MACHINE = "rpi3-tech"