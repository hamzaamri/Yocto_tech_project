# Remove gdbm from perl PACKAGECONFIG
PACKAGECONFIG:remove = "gdbm"