PROVIDES += "tar coreutils"
RPROVIDES:${PN} += "tar coreutils"